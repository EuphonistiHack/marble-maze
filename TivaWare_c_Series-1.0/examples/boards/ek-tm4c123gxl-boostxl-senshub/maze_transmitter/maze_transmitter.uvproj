# Keil uVision project maze_transmitter.uvproj, settings and files
target maze_transmitter (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: maze_transmitter
  AfterMake: fromelf --bin --output .\rvmdk\maze_transmitter.bin .\rvmdk\maze_transmitter.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: maze_transmitter.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c rgb.c
    ./: lprf.c maze_transmitter.c motion.c remoti_npi.c remoti_rtis.c remoti_uart.c startup_rvmdk.S
    ../../../../utils/: ringbuf.c uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
